Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Jun-Coffee Table 77x68 H40 Teak - ver4.ifc
Time: 2024-11-06T15:21:39
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (16)
Name
 | Jun-Coffee Table 77x68 H40 Teak_0 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_1 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_2 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_3 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_4 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_5 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_6 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_7 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_8 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_9 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_10 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_11 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_12 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_13 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_14 - ObjectType: SketchupGroup
 | Jun-Coffee Table 77x68 H40 Teak_15 - ObjectType: SketchupGroup
